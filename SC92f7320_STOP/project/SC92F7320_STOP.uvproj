# Keil uVision project SC92F7320_STOP.uvproj, settings and files
target STOP (MCS-51)
  device: SC92F7320 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: SC92F7320_STOP +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\lib;..\user;..\user\led;..\user\exit;..\user\stop_mode;..\user\TimeOut;..\user\timer;..\user\key
  group USER
    ./: STARTUP.A51
    ../user/: main.c system.c
    ../user/led/: led.c
    ../user/exit/: exit_interrupt.c
    ../user/stop_mode/: stop_mode.c
    ../user/TimeOut/: TimeOut.c
    ../user/timer/: timer.c
    ../user/key/: key.c
